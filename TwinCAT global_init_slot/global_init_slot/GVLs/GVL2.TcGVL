{attribute 'qualified_only'}
//{attribute 'global_init_slot' := '40500'}
VAR_GLOBAL   //49990
    nB : INT := 1000;
    nC : INT := 10;
END_VAR
