{attribute 'qualified_only'}
VAR_GLOBAL   //49990
    nA: INT := GVL2.nB*3;
END_VAR
