PROGRAM MAIN  //50000
VAR
    nVar1 : INT := GVL1.nA;
    nVar2 : INT;
END_VAR

nVar1 := nVar1 + 1;
nVar2 := GVL2.nC;

END_PROGRAM
